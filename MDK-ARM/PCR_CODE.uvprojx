# Keil uVision project PCR_CODE.uvprojx, settings and files
target PCR_CODE (ARM-ADS)
  device: STM32L476RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: PCR_CODE +hex
  AfterMake: fromelf --bin --output=.\bin\ .\PCR_CODE\PCR_CODE.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;                       ../Drivers/STM32L4xx_HAL_Driver/Inc;                       ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                       ../Middlewares/Third_Party/FatFs/src;                       ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;                       ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;                       ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                       ../Drivers/CMSIS/Include;                       ..\BSP;                       ..\USER;                       ..\APP;                       ..\UCOSII\CONFIG;                       ..\UCOSII\PORT;                       ..\UCOSII\CORE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\PCR_CODE.sct
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group BSP
    ../BSP/: bsp_w25qxx.c bsp.c bsp_spi.c bsp_printf.c bsp_ad7124.c bsp_tmc260.c bsp_max5401.c bsp_rtc.c retarget.c
  group USER
    ../USER/: tlsf.c sys_data.c motor.c rw_spiflash.c rw_udisk.c timer.c msg.c spiflash_fs.c ad7124.c DaCai_API.c DaCai_ProtoAnalysis.c timestamp.c display_code.c ring_buffer.c LIFO_buffer.c PID.c TempCalc.c misc.c DaCai_TouchEvent.c json.c protocol.c PD_DataProcess.c firmware_info.c sys_info.c
  group APP
    ../APP/: task_manage.c app_spiflash.c os_app_hooks.c app_udisk.c app_motor.c app_ad.c app_display.c app_temp.c app_fluo.c app_usart.c app_filetransmit.c
  group Application/User
    ../Src/: main.c gpio.c dma.c usbh_diskio.c fatfs.c user_diskio.c spi.c tim.c usart.c usb_host.c usbh_conf.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_hcd.c stm32l4xx_ll_usb.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 5.0.1, Data Exchange:JSON:Jansson 2.7.0
